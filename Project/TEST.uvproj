# Keil uVision project TEST.uvproj, settings and files
target NodeDevice_Project (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: NodeDevice +hex
  AfterMake: axf2bin.BAT
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD_VL
  c include: ..\CMSIS\CM3\CoreSupport;..\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\Libraries\inc;..\Libraries\src;..\Startup;..\User;..\Os\cfiles;..\Os\hfiles;..\BSP;..\App\cfiles;..\App\hfiles
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Startup
    ../Startup/: startup_stm32f10x_hd.s
  group User
    ../User/: main.c stm32f10x_it.c
  group CMSIS
    ../CMSIS/CM3/CoreSupport/: core_cm3.c
    ../CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group Libraries
    ../Libraries/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group Os
    ../Os/cfiles/: ostmr.c osled.c ostmr0.c osadc.c osdelay.c osiwdg.c oskey.c osrf315tx.c ostmr1.c osqtmr.c osusart1.c osusart2.c osusart.c
  group App
    ../App/cfiles/: appsensor.c appusart.c appkey.c appusarttest.c
